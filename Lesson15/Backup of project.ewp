# IAR project Backup of project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\ti\TivaWare_C_Series-2.2.0.295\inc; D:\ti\TivaWare_C_Series-2.2.0.295\driverlib; D:\Program Files\IAR Systems\Embedded Workbench 9.0\arm\inc\TexasInstruments; D:\Program Files\IAR Systems\Embedded Workbench 9.0\arm\CMSIS\Core\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\source\repos\Embedded\embedded_programming\Lesson10\project.icf
  ILINK.IlinkAdditionalLibs: D:\ti\TivaWare_C_Series-2.2.0.295\usblib\ewarm\Exe\usblib.a; D:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a; D:\ti\TivaWare_C_Series-2.2.0.295\grlib\ewarm\Exe\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: core_cm4.h delay.c delay.h lm4f120h5qr.h main.c startup_tm4c.c tm4c_cmsis.h
